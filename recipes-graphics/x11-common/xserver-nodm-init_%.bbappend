PACKAGECONFIG_remove = "blank"
PACKAGECONFIG_append = " nocursor"
